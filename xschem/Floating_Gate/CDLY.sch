v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {sg13g2_pr/cap_cmim.sym} 0 0 0 0 {name=C2
model=cap_cmim
w=80.0e-6
l=40.0e-6
m=3
spiceprefix=X}
C {devices/lab_pin.sym} 0 -30 0 0 {name=p11 sig_type=std_logic lab=dly8}
C {devices/gnd.sym} 0 30 0 0 {name=l26 lab=GND}
